# Keil uVision project craft.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: craft
  c flags: Optim=1
  c define: USE_USER_CONFIG
  c include: ..\src_library\STM32F10x_StdPeriph_Driver\inc;..\src_system;..\src_stm32;..\src_io;..\src_algori;..\src_math;..\src_craft;..\src_main_craft
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group library
    ../src_library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c
  group system
    ../src_system/: hardware.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_define.h error.c error.h
  group stm32
    ../src_stm32/: stm32_delay.c stm32_delay.h stm32_exti.c stm32_exti.h stm32_gpio.c stm32_gpio.h stm32_led.c stm32_led.h stm32_pwm.c stm32_pwm.h stm32_spi.c stm32_spi.h stm32_sys.c stm32_sys.h stm32_systick.c stm32_systick.h stm32_timer.c stm32_timer.h
  group main
    ../src_main_craft/: inter_timer.c main.c package_craft.c stm32_config.h user_config.h error_callback.c systick_callback.c
  group io
    ../src_io/: cc1101.c cc1101.h io_data.c io_data.h package.c package.h cc1101_mgr.c cc1101_mgr.h rf_mgr.h
  group algori
    ../src_algori/: code.c code.h strlib.c strlib.h
  group math
    ../src_math/: my_math.c my_math.h quat_unit.c quat_unit.h
  group craft
    ../src_craft/: calcu_pwm.c calcu_pwm.h craft_data.c craft_data.h mpu9250.h mpu9250_spi.c pid.h atti_align.c atti_align.h craft_cmd.c craft_cmd.h imu_attitude.c imu_attitude.h imu_normalize.c imu_normalize.h imu_physics.c imu_physics.h imu_smooth.c imu_smooth.h imu_sensor.c imu_sensor.h craft_type.h craft_conf.h
